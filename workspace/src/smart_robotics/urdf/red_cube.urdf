Commit message: Pick and place

File: workspace/src/smart_robotics/urdf/red_cube.urdf (robot description, URDF)
Before this commit: robot red_cube, 1 links, 0 joints
Links:
- link base_link: mass 0.1 -> 0.05
